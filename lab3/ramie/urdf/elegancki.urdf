Commit message: po majowce male pozadki

File: lab3/ramie/urdf/elegancki.urdf (robot description, URDF)
Before this commit: robot ramie, 6 links, 5 joints
Joints:
- joint box2_to_gripper_prismatic: origin xyz=0.55 0 0 -> xyz=0.55 0 -0.2 rpy=3.14 0 0
